# Keil uVision project UART.uvprojx, settings and files
target UART (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 002_UART +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\APPLICATION;..\..\..\DRIVER;..\..\..\SDK\components;..\..\..\SDK\components\ble\ble_advertising;..\..\..\SDK\components\ble\ble_dtm;..\..\..\SDK\components\ble\ble_racp;..\..\..\SDK\components\ble\ble_services\ble_ancs_c;..\..\..\SDK\components\ble\ble_services\ble_ans_c;..\..\..\SDK\components\ble\ble_services\ble_bas;..\..\..\SDK\components\ble\ble_services\ble_bas_c;..\..\..\SDK\components\ble\ble_services\ble_cscs;..\..\..\SDK\components\ble\ble_services\ble_cts_c;..\..\..\SDK\components\ble\ble_services\ble_dfu;..\..\..\SDK\components\ble\ble_services\ble_dis;..\..\..\SDK\components\ble\ble_services\ble_gls;..\..\..\SDK\components\ble\ble_services\ble_hids;..\..\..\SDK\components\ble\ble_services\ble_hrs;..\..\..\SDK\components\ble\ble_services\ble_hrs_c;..\..\..\SDK\components\ble\ble_services\ble_hts;..\..\..\SDK\components\ble\ble_services\ble_ias;..\..\..\SDK\components\ble\ble_services\ble_ias_c;..\..\..\SDK\components\ble\ble_services\ble_lbs;..\..\..\SDK\components\ble\ble_services\ble_lbs_c;..\..\..\SDK\components\ble\ble_services\ble_lls;..\..\..\SDK\components\ble\ble_services\ble_nus;..\..\..\SDK\components\ble\ble_services\ble_nus_c;..\..\..\SDK\components\ble\ble_services\ble_rscs;..\..\..\SDK\components\ble\ble_services\ble_rscs_c;..\..\..\SDK\components\ble\ble_services\ble_tps;..\..\..\SDK\components\ble\common;..\..\..\SDK\components\ble\nrf_ble_gatt;..\..\..\SDK\components\ble\nrf_ble_qwr;..\..\..\SDK\components\ble\peer_manager;..\..\..\SDK\components\boards;..\..\..\SDK\components\drivers_nrf\usbd;..\..\..\SDK\components\libraries\atomic;..\..\..\SDK\components\libraries\atomic_fifo;..\..\..\SDK\components\libraries\atomic_flags;..\..\..\SDK\components\libraries\balloc;..\..\..\SDK\components\libraries\bootloader\ble_dfu;..\..\..\SDK\components\libraries\bsp;..\..\..\SDK\components\libraries\button;..\..\..\SDK\components\libraries\cli;..\..\..\SDK\components\libraries\crc16;..\..\..\SDK\components\libraries\crc32;..\..\..\SDK\components\libraries\crypto;..\..\..\SDK\components\libraries\csense;..\..\..\SDK\components\libraries\csense_drv;..\..\..\SDK\components\libraries\delay;..\..\..\SDK\components\libraries\ecc;..\..\..\SDK\components\libraries\experimental_section_vars;..\..\..\SDK\components\libraries\experimental_task_manager;..\..\..\SDK\components\libraries\fds;..\..\..\SDK\components\libraries\fstorage;..\..\..\SDK\components\libraries\gfx;..\..\..\SDK\components\libraries\gpiote;..\..\..\SDK\components\libraries\hardfault;..\..\..\SDK\components\libraries\hci;..\..\..\SDK\components\libraries\led_softblink;..\..\..\SDK\components\libraries\log;..\..\..\SDK\components\libraries\log\src;..\..\..\SDK\components\libraries\low_power_pwm;..\..\..\SDK\components\libraries\mem_manager;..\..\..\SDK\components\libraries\memobj;..\..\..\SDK\components\libraries\mpu;..\..\..\SDK\components\libraries\mutex;..\..\..\SDK\components\libraries\pwm;..\..\..\SDK\components\libraries\pwr_mgmt;..\..\..\SDK\components\libraries\queue;..\..\..\SDK\components\libraries\ringbuf;..\..\..\SDK\components\libraries\scheduler;..\..\..\SDK\components\libraries\sdcard;..\..\..\SDK\components\libraries\sensorsim;..\..\..\SDK\components\libraries\slip;..\..\..\SDK\components\libraries\sortlist;..\..\..\SDK\components\libraries\spi_mngr;..\..\..\SDK\components\libraries\stack_guard;..\..\..\SDK\components\libraries\strerror;..\..\..\SDK\components\libraries\svc;..\..\..\SDK\components\libraries\timer;..\..\..\SDK\components\libraries\twi_mngr;..\..\..\SDK\components\libraries\twi_sensor;..\..\..\SDK\components\libraries\timer;..\..\..\SDK\components\libraries\twi_mngr;..\..\..\SDK\components\libraries\twi_sensor;..\..\..\SDK\components\libraries\usbd;..\..\..\SDK\components\libraries\usbd\class\audio;..\..\..\SDK\components\libraries\usbd\class\cdc;..\..\..\SDK\components\libraries\usbd\class\cdc\acm;..\..\..\SDK\components\libraries\usbd\class\hid;..\..\..\SDK\components\libraries\usbd\class\hid\generic;..\..\..\SDK\components\libraries\usbd\class\hid\kbd;..\..\..\SDK\components\libraries\usbd\class\hid\mouse;..\..\..\SDK\components\libraries\usbd\class\msc;..\..\..\SDK\components\libraries\util;..\..\..\SDK\components\nfc\ndef\conn_hand_parser;..\..\..\SDK\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\SDK\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\SDK\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\SDK\components\nfc\ndef\connection_handover\ac_rec;..\..\..\SDK\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\SDK\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\SDK\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\SDK\components\nfc\ndef\connection_handover\common;..\..\..\SDK\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\SDK\components\nfc\ndef\connection_handover\hs_rec;..\..\..\SDK\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\SDK\components\nfc\ndef\generic\message;..\..\..\SDK\components\nfc\ndef\generic\record;..\..\..\SDK\components\nfc\ndef\launchapp;..\..\..\SDK\components\nfc\ndef\parser\message;..\..\..\SDK\components\nfc\ndef\parser\record;..\..\..\SDK\components\nfc\ndef\text;..\..\..\SDK\components\nfc\ndef\uri;..\..\..\SDK\components\nfc\t2t_lib;..\..\..\SDK\components\nfc\t2t_lib\hal_t2t;..\..\..\SDK\components\nfc\t2t_parser;..\..\..\SDK\components\nfc\t4t_lib;..\..\..\SDK\components\nfc\t4t_lib\hal_t4t;..\..\..\SDK\components\nfc\t4t_parser\apdu;..\..\..\SDK\components\nfc\t4t_parser\cc_file;..\..\..\SDK\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\SDK\components\nfc\t4t_parser\tlv;..\..\..\SDK\components\softdevice\common;..\..\..\SDK\components\softdevice\s140\headers;..\..\..\SDK\components\softdevice\s140\headers\nrf52;..\..\..\SDK\external\fprintf;..\..\..\SDK\external\segger_rtt;..\..\..\SDK\external\utf_converter;..\..\..\SDK\integration\nrfx;..\..\..\SDK\integration\nrfx\legacy;..\..\..\SDK\modules\nrfx;..\..\..\SDK\modules\nrfx\drivers\include;..\..\..\SDK\modules\nrfx\hal;..\..\..\SDK\modules\nrfx\mdk;..\..\..\SDK\components\libraries\uart
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\DRIVER;..\APPLICATION;..\..\..\SDK;..\..\..\SDK\components;..\..\..\SDK\components\boards;..\..\..\SDK\components\drivers_nrf\nrf_soc_nosd;..\..\..\SDK\components\libraries\atomic;..\..\..\SDK\components\libraries\balloc;..\..\..\SDK\components\libraries\bsp;..\..\..\SDK\components\libraries\delay;..\..\..\SDK\components\libraries\experimental_section_vars;..\..\..\SDK\components\libraries\fifo;..\..\..\SDK\components\libraries\log;..\..\..\SDK\components\libraries\log\src;..\..\..\SDK\components\libraries\memobj;..\..\..\SDK\components\libraries\ringbuf;..\..\..\SDK\components\libraries\strerror;..\..\..\SDK\components\libraries\uart;..\..\..\SDK\components\libraries\util;..\..\..;..\..\..\SDK\external\fprintf;..\..\..\SDK\integration\nrfx;..\..\..\SDK\integration\nrfx\legacy;..\..\..\SDK\modules\nrfx;..\..\..\SDK\modules\nrfx\drivers\include;..\..\..\SDK\modules\nrfx\hal;..\..\..\SDK\modules\nrfx\mdk
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0xda000
  memory RVCT9: RAM 0x20002a98 size 0x3d568
  link misc: --diag_suppress 6330
  group Application
    ../APPLICATION/: main.c sdk_config.h
  group Board Definition
    ../../../SDK/components/boards/: boards.c
  group nRF_Drivers
    ../../../SDK/integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_saadc.h nrf_drv_clock.c
    ../../../SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../SDK/modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c nrfx_saadc.c nrfx_timer.c
    ../../../SDK/modules/nrfx/hal/: nrf_saadc.h
  group nRF_Libraries
    ../../../SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../SDK/components/libraries/fifo/: app_fifo.c
    ../../../SDK/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../SDK/components/libraries/memobj/: nrf_memobj.c
    ../../../SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../SDK/components/libraries/timer/: app_timer.c
    ../../../SDK/modules/nrfx/hal/: nrf_gpio.h nrf_gpiote.h
    ../../../SDK/integration/nrfx/legacy/: nrf_drv_gpiote.h
    ../../../SDK/modules/nrfx/drivers/src/: nrfx_gpiote.c
    ../../../SDK/components/libraries/button/: app_button.c
  group nRF_Log
    ../../../SDK/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group DRIVER
    ../../../DRIVER/: led.c uart.c ADC.c button.c
  group Board Support
    ../../../SDK/components/libraries/bsp/: bsp.c bsp_btn_ant.c
    ../../../SDK/external/utf_converter/: utf.c
  group BLE
    ../../../SDK/components/ble/ble_advertising/: ble_advertising.c
    ../../../SDK/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../../SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group BLE Servces
    ../../../SDK/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../SDK/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../SDK/components/ble/ble_services/ble_hts/: ble_hts.c
  group BLE Softdevice
    ../../../SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0, Device:StartupConfig 8.17.0
